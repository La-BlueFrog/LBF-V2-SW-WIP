# Keil uVision project STM32F401_X-Nucleo-VL6180X.uvproj, settings and files
target STM32F401_X-Nucleo-VL6180X Configuration (ARM-ADS)
  device: STM32F401RE STMicroelectronics
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x0807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F401_X-Nucleo-VL6180X Configuration +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE
  c misc: --C99
  c include: ..\..\Inc;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Drivers\CMSIS\Include;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\BSP\X-NUCLEO-IKP01A;..\..\..\..\core\inc;..\..\..\..\platform\Nucleo_STM32F401
  asm include: ..\..\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f401xe.s
  group Application/User
    ../../Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
    ../../../../core/src/: vl6180x_api.c
    ../../../../platform/cci-i2c/: vl6180x_i2c.c
    ../../Drivers/BSP/X-NUCLEO-IKP01A/: x_nucleo_ikp01a_display.c x_nucleo_ikp01a1.c
  group Drivers/CMSIS
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c
